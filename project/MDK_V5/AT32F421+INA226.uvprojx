# Keil uVision project AT32F421+INA226.uvprojx, settings and files
target AT32F421+INA226 (6180000::V6.18::ARMCLANG)
  device: -AT32F421G8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: StupidMeterB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=4 wLevel=3
  c define: AT32F421G8U7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c lcd.c lcd_init.c delay.c SEGGER_RTT.c SEGGER_RTT_printf.c I2C.c Queue.c w25qxx.c TMR3.c
  group firmware
    ../../libraries/drivers/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
