# Keil uVision project INA226.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: INA226 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: main.C lcd.c lcd_init.c I2C.c
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
